DATA SEGMENT
NUM1 DD 56747978H
NUM2 DD 12345678H
DIFF DW ?
BORROW DB ?
DATA ENDS
CODE SEGMENT
ASSUME CS:CODE,DS:DATA
START:
MOV AX,DATA
MOV DS,AX
LEA SI,NUM1
LEA DI,NUM2
LEA BX,DIFF
MOV CX,04
BACK:
MOV AL,[SI]
SUB AL,[DI]
DAS
MOV [BX],AL
INC SI
INC DI
INC BX
LOOP BACK
SBB BORROW,0
MOV AH,4CH
INT 21H
CODE ENDS
END START

