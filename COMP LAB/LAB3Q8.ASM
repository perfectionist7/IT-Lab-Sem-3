DATA SEGMENT
ARRAY dB 12H,23H,45H,56H,67H,78H,90H,0ABH,0BCH,0CDH
SUM dW ?
CARRY db ?
DATA ENDS
CODE SEGMENT
ASSUME CS:CODE,DS:DATA
START:
MOV AX,DATA
MOV DS,AX
CLC
LEA SI,ARRAY
MOV CX,0AH
MOV AX,0
BACK:
MOV BL,[SI]
MOV BH,0
ADD AX,BX
INC SI
LOOP BACK
MOV SUM,AX
MOV AH,4CH
INT 21H
CODE ENDS
END START



