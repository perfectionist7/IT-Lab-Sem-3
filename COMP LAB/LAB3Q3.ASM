DATA SEGMENT
NUM1 dD 12345678H
NUM2 dD 0ABCDEF12H
SUM dD ?
CARRY db ?
DATA ENDS
CODE SEGMENT
ASSUME CS:CODE,DS:DATA
START:
MOV AX,DATA
MOV DS,AX
CLC
LEA BX,SUM
LEA SI,NUM1
LEA DI,NUM2
MOV CX,02
BACK:
MOV AX,[SI]
ADC AX,[DI]
MOV [BX],AX
INC SI
INC SI
INC DI
INC DI
INC BX
INC BX
LOOP BACK
ADC CARRY,0
MOV AH,4CH
INT 21H
CODE ENDS
END START



