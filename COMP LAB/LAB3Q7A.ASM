DATA SEGMENT
NUM1 DD 12345678H
NUM2 DD 12345678H
SUM DW ?
CARRY DB ?
DATA ENDS
CODE SEGMENT
ASSUME CS:CODE,DS:DATA
START:
MOV AX,DATA
MOV DS,AX
LEA BX,SUM
LEA SI,NUM1
LEA DI,NUM2
MOV CX,04
CLC
BACK:
MOV AL,[SI]
ADD AL,[DI]
DAA
MOV [BX],AL
INC SI
INC DI
INC BX
LOOP BACK
ADC CARRY,0
MOV AH,4CH
INT 21H
CODE ENDS
END START


