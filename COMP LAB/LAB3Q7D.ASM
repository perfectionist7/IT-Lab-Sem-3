DATA SEGMENT
NUM1 DT 123456789ABCDEF12345H
NUM2 DT 987654321123456789ABH
DIFF DD ?    
BORROW DB ?
DATA ENDS
CODE SEGMENT
ASSUME CS:CODE,DS:DATA
START:
MOV AX,DATA
MOV DS,AX
CLC
LEA BX,DIFF
LEA SI,NUM1
LEA DI,NUM2
MOV CX,05
CLC
BACK:
MOV AL,[SI]
SBB AL,[DI]
DAS
MOV [BX],AX
INC SI
INC SI
INC DI
INC DI
INC BX
INC BX
LOOP BACK
SBB BORROW,0
DAS
MOV AH,4CH
INT 21H
CODE ENDS
END START

